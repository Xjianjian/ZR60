# Keil uVision project My_Project.uvproj, settings and files
target My_Project (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: My_Project +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\WZY\LED;..\WZY\LCD12864;..\WZY\KEYBOARD;..\WZY\BUTTON;..\WZY\DMA;..\ZNFAT;..\WZY\SDIO;..\TEXT;..\WZY\IIC;..\WZY\IIS;..\WZY\WM8978;..\WZY\AT24C02;..\AUDIOCODEC\WAVCODEC;..\MALLOC;..\WZY\SRAM;..\APP;..\WZY\TIMER;..\AUDIOCODEC\MP3;..\AUDIOCODEC\MP3\helix
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: audioplayer.c
  group ADUIOCODEC_MP3
    ../AUDIOCODEC/MP3/: mp3play.c
    ../AUDIOCODEC/MP3/helix/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
    ../AUDIOCODEC/MP3/helix/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group AUDIOCODEC_WAV
    ../AUDIOCODEC/WAVCODEC/: wavcodec.c
  group BSP
    ../BSP/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group MALLOC
    ../MALLOC/: malloc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group TEXT
    ../TEXT/: fontupd.c text.c exfuns.c
  group WZY
    ../WZY/LED/: led.c
    ../WZY/LCD12864/: lcd12864.c
    ../WZY/KEYBOARD/: keyboard.c
    ../WZY/BUTTON/: button.c
    ../WZY/SDIO/: sdio_sdcard.c
    ../WZY/WM8978/: wm8978.c
    ../WZY/IIS/: iis.c
    ../WZY/IIC/: iic.c
    ../WZY/DMA/: dma.c
    ../WZY/AT24C02/: at24c02.c
    ../WZY/SRAM/: sram.c
    ../WZY/TIMER/: timer3.c
  group ZNFAT
    ../ZNFAT/: deviceio.c znFAT.c
  group 开发记录
    ../开发记录/: 开发记录.txt 需要完成的任务.txt
