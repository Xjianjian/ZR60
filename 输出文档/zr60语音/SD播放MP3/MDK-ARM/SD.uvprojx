# Keil uVision project SD.uvprojx, settings and files
target SD (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SD
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\Drivers\mp3\helix
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal_sd.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2s.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/User
    ../Src/: bsp_driver_sd.c usart.c main.c fatfs.c gpio.c sdio.c stm32f1xx_hal_msp.c stm32f1xx_it.c i2s.c wave.c wm8978.c dma.c mp3.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Mp3
    ../Drivers/mp3/helix/: assembly.h bitstream.c buffers.c coder.h dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3common.h mp3dec.c mp3dec.h mp3tabs.c mpadecobjfixpt.h scalfact.c statname.h stproc.c subband.c trigtabs.c
    ../Drivers/mp3/helix/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
software components: CMSIS:CORE 3.40.0
