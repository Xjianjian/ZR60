# Keil uVision project bryjh.uvprojx, settings and files
target Libraries (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bryjh
  c flags: v6Lang=1 v6LangP=1
  c define: USE_STM324xG_EVAL, STM32F4XX, USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Source;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\UserFile;..\BSP;..\user_Lib;..\APP;..\FreeRTOS\include;..\FreeRTOS\Port;..\FreeRTOS\Sourse;..\LCD_File;..\GUILib;..\FATFS;..\FATFS\option;..\Mp3Lib;..\Mp3Lib\pub;..\Mp3Lib\real;..\Mp3Lib\real\arm;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Lib\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ../UserFile/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group UserFiles
    ../UserFile/: MainFile.c stm32f4xx_it.c includes.h
  group STM32F4xx_StdPeriph_Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_dac.c
  group STM32F4xx_StdPeriph_FPU_Lib
    ../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group BSP
    ../LCD_File/: Lcd.c TouchScreen.c
    ../user_Lib/: BSP.c
  group APP
    ../APP/: GUI_Process.c LHL_MP3_Decoder.c
  group FreeRTOS
    ../FreeRTOS/Sourse/: croutine.c list.c queue.c tasks.c timers.c heap_4.c
    ../FreeRTOS/Port/: port.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group FATFS
    ../FATFS/: diskio.c ff.c sdio_sd.c ffconf.h
    ../FATFS/option/: cc936.c
  group GUI
    ../GUILib/: LHL_GUICfg.h lhlgui.lib
  group mp3lib_general
    ../Mp3Lib/: mp3_play.c mp3dec.c mp3tabs.c
  group mp3lib_inc
    ../Mp3Lib/pub/: mp3.h mp3common.h mp3dec.h mpadecobjfixpt.h statname.h
  group mp3lib_src
    ../Mp3Lib/real/: bitstream.c buffers.c dct32.c dqchan.c dequant.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c
    ../Mp3Lib/real/arm/: asmmisc.S asmpoly_thumb2.S
software components: CMSIS:CORE 5.1.1
