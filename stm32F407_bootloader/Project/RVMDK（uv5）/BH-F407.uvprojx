# Keil uVision project BH-F407.uvprojx, settings and files
target bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZZW_Bootloader +hex
  c flags: OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\stm32F407_bootloader;..\..\Lwip\App;..\..\Lwip\Bsp;..\..\Lwip\Bsp\LAN8742A;..\..\Lwip\lwip-1.4.1;..\..\Lwip\lwip-1.4.1\port;..\..\Lwip\lwip-1.4.1\port\arch;..\..\Lwip\lwip-1.4.1\port\Standalone;..\..\Lwip\lwip-1.4.1\src\include;..\..\Lwip\lwip-1.4.1\src\include\ipv4;..\..\Lwip\lwip-1.4.1\src\include\lwip;..\..\Lwip\lwip-1.4.1\src\include\netif;..\..\Ecal\BtnFltr;..\..\Ecal\UartComn;..\..\Ecal\MemIf;..\..\APP;..\..\APP\BlackListMng;..\..\APP\SeverNewsPush;..\..\APP\NewsPull;..\..\Ecal;..\..\Ecal\JsonIf;..\..\Ecal\Mcu_Init;..\..\Service;..\..\Complex;..\..\Complex\FATFS;..\..\Ecal\crc32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7fff
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DOC
    ../../: 必读说明.txt
  group Service
    ../../Complex/systick/: bsp_SysTick.c
    ../../Complex/iwdg/: bsp_iwdg.c
    ../../Ecal/MemIf/: MemIf_cfg.c MemIf.c
    ../../Service/: main.c stm32f4xx_it.c
    ../../Complex/usart/: bsp_debug_usart.c
    ../../Ecal/crc32/: crc32.c
