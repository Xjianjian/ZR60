# Keil uVision project BH-F407.uvprojx, settings and files
target ZR60 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\ZR60_v1.0_freeRTOS;..\..\Lwip\App;..\..\Lwip\Bsp;..\..\Lwip\Bsp\LAN8742A;..\..\Lwip\lwip-1.4.1;..\..\Lwip\lwip-1.4.1\port;..\..\Lwip\lwip-1.4.1\port\arch;..\..\Lwip\lwip-1.4.1\port\Standalone;..\..\Lwip\lwip-1.4.1\src\include;..\..\Lwip\lwip-1.4.1\src\include\ipv4;..\..\Lwip\lwip-1.4.1\src\include\lwip;..\..\Lwip\lwip-1.4.1\src\include\netif;..\..\APP;..\..\Ecal;..\..\Ecal\JsonIf;..\..\Ecal\Mcu_Init;..\..\Service;..\..\Complex;..\..\Complex\FATFS;..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\FreeRTOS;..\..\polarssl-1.0.0\include;..\..\polarssl-1.0.0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5ffff
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FatFs
    ../../Complex/FATFS/: diskio.c ff.c tm_stm32f4_fatfs.c
    ../../Complex/FATFS/option/: cc936.c
  group Complex
    ../../Complex/flash/: fatfs_flash_spi.c
    ../../Complex/usart/: bsp_debug_usart.c
    ../../Complex/i2c/: bsp_i2c_gpio.c
    ../../Complex/led/: bsp_led.c
    ../../Complex/systick/: bsp_SysTick.c
    ../../Complex/wm8978/: bsp_wm8978.c
    ../../Complex/rcc/: bsp_clkconfig.c
    ../../Complex/iwdg/: bsp_iwdg.c
    ../../Complex/adc/: bsp_adc.c
  group Lwip
    ../../Lwip/App/: netconf.c dhcpClient.c
    ../../Lwip/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Lwip/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../Lwip/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../Lwip/lwip-1.4.1/src/netif/: etharp.c
    ../../Lwip/lwip-1.4.1/port/Standalone/: ethernetif.c
    ../../Lwip/Bsp/LAN8742A/: LAN8742A.c stm32f429_eth.c
    ../../Lwip/lwip-1.4.1/port/arch/: sys_arch.c
    ../../Lwip/App/NetConnIf/: NetConnIf.c NetConnIf_Cfg.c
  group Ecal
    ../../Ecal/JsonIf/: cJSON.c
    ../../Ecal/Mcu_Init/: Mcu_Init.c
    ../../Ecal/crc32/: crc32.c
  group Service
    ../../Service/: main.c stm32f4xx_it.c
    ../../Service/SleepMng/: SleepMng.c
  group freeRTOS
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../FreeRTOS/Source/portable/MemMang/: heap_2.c heap_4.c
  group polarSSL
    ../../polarssl-1.0.0/library/: aes.c arc4.c base64.c bignum.c camellia.c certs.c cipher.c cipher_wrap.c debug.c des.c dhm.c error.c havege.c md.c md_wrap.c md2.c md4.c md5.c net.c padlock.c pem.c rsa.c sha1.c sha2.c sha4.c ssl_cli.c ssl_tls.c timing.c x509parse.c xtea.c
    ../../polarssl-1.0.0/: retarget.c
