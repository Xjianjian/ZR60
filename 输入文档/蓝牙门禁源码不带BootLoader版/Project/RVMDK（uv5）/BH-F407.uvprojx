# Keil uVision project BH-F407.uvprojx, settings and files
target EEPROM (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZZW_BL_SOUND_0.5 +hex
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c misc: -c99
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/usart/: bsp_debug_usart.c
    ../../User/led/: bsp_led.c
    ../../User/i2c/: bsp_i2c_ee.c bsp_i2c_gpio.c
    ../../User/timeStamp/: time_stamp.c
    ../../User/systick/: bsp_SysTick.c
    ../../User/key/: bsp_exti.c
    ../../User/rtc/: rtc.c
    ../../User/display/: display.c
    ../../User/tim/: bsp_basic_tim.c
    ../../User/beep/: bsp_beep.c
    ../../User/sm3/: SM3.c
    ../../User/recorder/: Recorder.c
    ../../User/soundwave/: soundwave.c
    ../../User/usart3/: usart3.c
    ../../User/usart4/: usart4.c
    ../../User/usart5/: usart5.c
    ../../User/wm8978/: bsp_wm8978.c
    ../../User/auxdata/: aux_data.c
    ../../User/flash/: fatfs_flash_spi.c
    ../../User/sram/: bsp_sram.c
    ../../User/malloc/: malloc.c
    ../../User/wdata/: wdata.c
    ../../User/adc/: bsp_adc.c
    ../../User/keyinput/: bsp_input.c
    ../../User/readcard/: readcard.c
    ../../User/iwdg/: bsp_iwdg.c
    ../../User/rcc/: bsp_clkconfig.c
  group DOC
    ../../: 必读说明.txt
  group FatFs
    ../../User/FATFS/: diskio.c ff.c tm_stm32f4_fatfs.c
    ../../User/FATFS/option/: cc936.c
