# Keil uVision project ZR60_v1.0.uvprojx, settings and files
target ZR60_v1.0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ZR60_v1.0
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Drivers/CMSIS/Include;  ../Middlewares/Third_Party/LwIP/src/include;  ../Middlewares/Third_Party/LwIP/system;  ../Middlewares/Third_Party/LwIP/src/include/lwip;  ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;  ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;  ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;  ../Middlewares/Third_Party/LwIP/src/include/netif;  ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;  ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;  ../Middlewares/Third_Party/LwIP/src/include/posix;  ../Middlewares/Third_Party/LwIP/src/include/posix/sys;  ../Middlewares/Third_Party/LwIP/system/arch;  ..\Middlewares\Third_Party\LwIP\App;  ..\Middlewares
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c list.c tasks.c croutine.c timers.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_eth.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c
  group Application/User
    ../Src/: stm32f4xx_it.c main.c freertos.c stm32f4xx_hal_msp.c ethernetif.c lwip.c gpio.c usart.c iwdg.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ipcp.c ecp.c pppoe.c mppe.c lcp.c eui64.c ccp.c multilink.c ppp.c upap.c chap-md5.c auth.c pppol2tp.c fsm.c demand.c eap.c vj.c pppcrypt.c chap_ms.c magic.c pppos.c chap-new.c pppapi.c utils.c ipv6cp.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_msg.c netifapi.c api_lib.c sockets.c netdb.c netbuf.c tcpip.c err.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: sha1.c arc4.c des.c md4.c md5.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_addr.c icmp6.c ip6_frag.c mld6.c ip6.c nd6.c ethip6.c inet6.c dhcp6.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: etharp.c ip4_addr.c ip4_frag.c ip4.c icmp.c autoip.c igmp.c dhcp.c
    ../Middlewares/Third_Party/LwIP/src/core/: raw.c init.c netif.c tcp.c pbuf.c timeouts.c def.c inet_chksum.c mem.c memp.c ip.c tcp_out.c tcp_in.c dns.c sys.c stats.c udp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c slipif.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group App/LwIP
    ../Middlewares/Third_Party/LwIP/App/: dnsAnalysis.c ntpclient.c dhcpClient.c tcp_client_LngConnect.c
    ../Middlewares/Third_Party/LwIP/App/NetConnIf/: NetConnIf.c NetConnIf_Cfg.c
  group Middlewares/ECU
    ../Middlewares/Ecal/JsonIf/: cJSON.c JsonIf.c
software components: CMSIS:CORE 4.1.0
